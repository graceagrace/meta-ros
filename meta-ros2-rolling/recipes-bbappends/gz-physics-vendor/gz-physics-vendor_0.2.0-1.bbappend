# Copyright (c) 2024 Wind River Systems, Inc.

<<<<<<< HEAD
export GZ_RELAX_VERSION_MATCH="1"

ROS_BUILD_DEPENDS += "gz-physics7"
=======
ROS_BUILD_DEPENDS += "gz-physics8"
>>>>>>> master-next
