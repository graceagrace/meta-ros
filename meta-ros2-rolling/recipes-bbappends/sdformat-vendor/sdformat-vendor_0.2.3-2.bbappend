# Copyright (c) 2024 Wind River Systems, Inc.

DEPENDS += "sdformat"

<<<<<<< HEAD
export GZ_RELAX_VERSION_MATCH="1"

=======
>>>>>>> origin/master-next
inherit ros_insane_dev_so
