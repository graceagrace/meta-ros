# Copyright (c) 2024 Wind River Systems, Inc.

<<<<<<< HEAD
export GZ_RELAX_VERSION_MATCH="1"

ROS_BUILD_DEPENDS += "gz-rendering8"

ROS_BUILDTOOL_DEPENDS += "cppcheck-native doxygen-native"
=======
ROS_BUILD_DEPENDS += "gz-rendering9"

ROS_BUILDTOOL_DEPENDS += "cppcheck-native doxygen-native"

inherit ros_insane_dev_so
>>>>>>> master-next
