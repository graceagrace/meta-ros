# Copyright (c) 2024 Wind River Systems, Inc.

<<<<<<< HEAD
ROS_BUILD_DEPENDS += "gz-fuel-tools9"
=======
ROS_BUILD_DEPENDS += "gz-fuel-tools10"

inherit ros_insane_dev_so
>>>>>>> master-next

BBCLASSEXTEND = "native nativesdk"
