# Copyright (c) 2023 Wind River Systems, Inc.

<<<<<<< HEAD
=======
LICENSE = "BSD-3-Clause"

>>>>>>> origin/master-next
ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-runtime-native \
"
