LICENSE = "BSD & LGPL-2.0 & Apache-2.0"