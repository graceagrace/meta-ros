# Copyright (c) 2020 LG Electronics, Inc.

<<<<<<< HEAD
=======
LICENSE = "BSD-3-Clause"

>>>>>>> master-next
ROS_BUILD_DEPENDS += " \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
"
