inherit pkgconfig

DEPENDS += "gazebo11"