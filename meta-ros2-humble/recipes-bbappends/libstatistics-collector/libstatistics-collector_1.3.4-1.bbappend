# Copyright (c) 2023 Wind River Systems, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \
<<<<<<< HEAD
    file://0001-make-moving-average-statistics-dtor-virtual.patch \
=======
    file://0002-make-moving-average-statistics-dtor-virtual.patch \
>>>>>>> master-next
"
